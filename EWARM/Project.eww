<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\BRICK5_H743_176.ewp</path>
  </project>
  <batchBuild />
</workspace>
